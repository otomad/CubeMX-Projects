# Keil uVision project SPI_Communication.uvprojx, settings and files
target SPI_Communication (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI_Communication +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport;..\Project;..\STM32F4xx_HAL_Driver\Inc;..\User\delay;..\User\LCD;..\User\LED;..\User\SDRAM;..\User\SPI_Communication;..\User\stm32f4xx_it;..\User\stm32f429_Winner;..\User\usart
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: main.c
    ../User/stm32f4xx_it/: stm32f4xx_it.c
    ../CMSIS/DeviceSupport/: system_stm32f4xx.c
  group User
    ../User/stm32f429_Winner/: stm32f429_winner.c
    ../User/delay/: delay.c
    ../User/LCD/: ltdc.c lcd.c
    ../User/SDRAM/: sdram.c
    ../User/SPI_Communication/: spi_communication.c
    ../User/usart/: usart.c
  group HAL_Driver
    ../STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
  group CMSIS
    ../CMSIS/CoreSupport/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../CMSIS/DeviceSupport/: startup_stm32f429xx.s
